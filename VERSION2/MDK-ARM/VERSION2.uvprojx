# Keil uVision project VERSION2.uvprojx, settings and files
target VERSION2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: VERSION2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;                                                                               ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                               ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                               ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                               ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                               ../Drivers/CMSIS/Include;                                                                               ..\MDK-ARM;                                                                               ..\Application;                                                                               ..\BSP;                                                                               ..\Components\support;                                                                               ..\Components\devices;                                                                               ..\Components\controller;                                                                               ..\Components\algorithm;                                                                               ..\USER_driver;                                                                               ..\Components\algorithm\Include
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c crc.c dma.c i2c.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application
    ../Application/: Callback.c
    ./: user_task.c
  group BSP
    ../BSP/: bsp_iic.c bsp_delay.c bsp_spi.c bsp_flash.c bsp_rng.c bsp_can.c
  group Drivers
    ../USER_driver/: ist8310.c bmi088.c bmi088_driver.c
  group Algorithm
    ../Components/algorithm/: AHRS_middleware.c user_lib.c AHRS.lib arm_cortexM4lf_math.lib
    ./: filter.c matrix.c
  group Controller
    ../Components/controller/: pid.c
  group Devices
    ../Components/devices/: door_servo.c
    ../USER_driver/: CAN_receive.c
    ./: frame.c codemove.c
  group Support
    ./: readme.md
software components: CMSIS:CORE 4.3.0
